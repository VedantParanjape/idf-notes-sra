## 10/hello_world_kconfig/main/Kconfig
```kconfig
menu "Value of i"
    config VALUE_OF_I
        int "initial value of i"
        default 0
        help
            "set value of i"
endmenu
```
